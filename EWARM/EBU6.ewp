# IAR project EBU6.ewp, settings and files
configuration EBU6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743IG ST STM32H743IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ..\Core\Inc\Comm; ..\Core\Inc\Core; ..\Core\Inc\Global; ..\Core\Inc\Peref; ..\Core\Inc\Stat; ..\Core\Inc\Vector
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EBU6.hex
  ILINK.IlinkOutputFile: EBU6.out
  ILINK.IlinkIcfFile: E:\WorkOther\EBU6\EWARM\stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: add_ValueConv.c main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/User/Core/Comm
    ../Core/Src/Comm/: comm.c drv_modbus.c
  group Application/User/Core/Core
    ../Core/Src/Core/: aci.c core_InverterControl.c core_Menu.c core_Protections.c core_ProtectionsAlarm.c core_ProtectionSHC.c core_TorqueObserver.c core_VlvDrvCtrl.c g_Core.c volt_calc.c
  group Application/User/Core/Global
    ../Core/Src/Global/: g_InterruptUpdate.c g_Ram.c
  group Application/User/Core/Peref
    ../Core/Src/Peref/: CMS58M.c peref.c peref_ApFilter1.c peref_ApFilter3.c peref_Calibs.c peref_Clock.c peref_display.c peref_SensObserver.c peref_SinObserver.c
  group Application/User/Core/Stat
    ../Core/Src/Stat/: stat.c stat_fm25v10.c
  group Application/User/Core/Vector
    ../Core/Src/Vector/: pid_regulator.c speed_torq_ctrl.c sto_pll_speed_pos_fdbk.c vector.c
  group Application/User/Inc
    ../Core/Inc/: add_ValueConv.h csl_io.h csl_memory.h delay.h main.h std.h stm32h7xx_hal_conf.h stm32h7xx_it.h
  group Application/User/Inc/Comm
    ../Core/Inc/Comm/: comm.h drv_modbus.h modbus_rtu.h responses.h
  group Application/User/Inc/Core
    ../Core/Inc/Core/: aci.h core_InverterControl.h core_Menu.h core_MenuGlobal.h core_MenuParams.h core_Protections.h core_ProtectionsAlarm.h core_ProtectionSHC.h core_TorqueObserver.h core_VlvDrvCtrl.h g_Core.h peref_ApFilter3.h volt_calc.h
  group Application/User/Inc/Global
    ../Core/Inc/Global/: g_InterruptUpdate.h g_Ram.h g_structs.h
  group Application/User/Inc/Peref
    ../Core/Inc/Peref/: peref.h peref_ApFilter1.h peref_ApFilter3.h peref_Calibs.h peref_Clock.h peref_displ.h peref_display.h peref_displhal.h peref_SensObserver.h peref_SinObserver.h
  group Application/User/Inc/Stat
    ../Core/Inc/Stat/: stat.h stat_fm25v10.h
  group Application/User/Inc/Vector
    ../Core/Inc/Vector/: mc_math.h mc_type.h pid_regulator.h speed_pos_fdbk.h speed_torq_ctrl.h sto_pll_speed_pos_fdbk.h sto_speed_pos_fdbk.h vector.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
